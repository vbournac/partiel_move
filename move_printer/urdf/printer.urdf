Commit message: code updated finished

File: move_printer/urdf/printer.urdf (robot description, URDF)
Before this commit: robot printer3D, 6 links, 5 joints
Joints:
- joint base_to_x: origin (none) -> xyz=0 0 0.35 rpy=0 0 0
